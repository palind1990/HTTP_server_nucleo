# Keil uVision project HTTP_Server.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT6: RAM 0x20010000 size 0x1000
  memory RVCT9: RAM 0x20011000 size 0x3f000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c HTTP_Server.c HTTP_Server_CGI.c
    Web/: Web.c
  group Web files
    ./Web/: pg_header.inc pg_footer.inc ad.cgi ad.cgx buttons.cgi buttons.cgx language.cgi lcd.cgi leds.cgi network.cgi system.cgi tcp.cgi xml_http.js home.png keil.gif logo.gif llblue.jpg pabb.gif vives_logo.png index.cgi button.cgi script.js
  group Documentation
    ./: Abstract.txt
target Release (6160000::V6.16::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: as above
  output: HTTP_Server
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Network:CORE 7.15.0, Network:CORE 7.15.0, Network:Interface:ETH 7.15.0, Network:Service:Web Server Compact 7.15.0, Network:Socket:TCP 7.15.0, Network:Socket:UDP 7.15.0, Board Support:Buttons 1.1.1, Board Support:Drivers:SDRAM 1.1.1, Board Support:Graphic LCD 1.1.1, Board Support:LED 1.1.1, CMSIS Driver:Ethernet MAC 1.9.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, Device:STM32Cube Framework:Classic 1.2.8, Device:STM32Cube HAL:ADC 1.2.8, Device:STM32Cube HAL:Common 1.2.8, Device:STM32Cube HAL:Cortex 1.2.8, Device:STM32Cube HAL:DMA 1.2.8, Device:STM32Cube HAL:GPIO 1.2.8, Device:STM32Cube HAL:LTDC 1.2.8, Device:STM32Cube HAL:PWR 1.2.8, Device:STM32Cube HAL:RCC 1.2.8, Device:STM32Cube HAL:SDRAM 1.2.8, Device:STM32Cube HAL:SRAM 1.2.8, Device:Startup 1.2.5
